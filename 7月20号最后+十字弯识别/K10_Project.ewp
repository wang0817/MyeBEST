# IAR project K10_Project.ewp, settings and files
configuration Flash_512K (ARM, debug)
  General.OGChipSelectEditMenu: MK10DN512Zxxx10 Freescale MK10DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR
  ICCARM.CCIncludePath2: Library\CPU; Library\Drivers\ADC; Library\Drivers\FTM; Library\Drivers\GPIO; Library\Drivers\PIT; Library\Drivers\I2C; Library\Drivers\UART; Library\Drivers\FTFL; MyFunction; SD_System; Delay; System_Init; OLED; ZLG7290; Simple_AD; Make_Desicion; Make_Desicion\Judge_Way; Make_Desicion\Speed_Control; Source; Peripheral_Oparation; Balance_control
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: K10_Project.srec
  ILINK.IlinkOutputFile: K10_Project.out
  ILINK.IlinkIcfFile: Linker\512KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM_128K (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: Library\CPU; Library\Drivers\ADC; Library\Drivers\FTM; Library\Drivers\GPIO; Library\Drivers\PIT; System_Init; Source; OLED; SD_System; Simple_AD; Delay; Make_Desicion
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: Linker\128KB_Ram.icf
  group Balance_control
    Balance_control/: Balance_control.c Balance_control.h
  group Delay
    Delay/: Delay.c
  group Jude_Way
    Delay/: Delay.h
    Make_Desicion/Judge_Way/: Judge_Way.c Judge_Way.h JudgeWay_byQue.c JudgeWay_byQue.h
  group Library/CPU
    Library/CPU/: KinetisConfig.h KinetisCrt0.s KinetisOperate.c KinetisVectors.c KinetisVectors.h MK10N512VMD100.h StartupCode.c
  group Library/Drivers/ADC
    Library/Drivers/ADC/: adc.c adc.h
  group Library/Drivers/FTFL
    Library/Drivers/FTFL/: FTFL.c FTFL.h
  group Library/Drivers/FTM
    Library/Drivers/FTM/: ftm.c ftm.h
  group Library/Drivers/GPIO
    Library/Drivers/GPIO/: gpio.c gpio.h
  group Library/Drivers/I2C
    Library/Drivers/I2C/: I2C_Driver.c I2C_Driver.h
  group Library/Drivers/PIT
    Library/Drivers/PIT/: pit.c pit.h
  group Library/Drivers/UART
    Library/Drivers/UART/: UART.c UART.h
  group Linker
    Linker/: 128KB_Ram.icf 512KB_Pflash.icf
  group Make_Decision
    Make_Desicion/: Motor_Decision.c Motor_Decision.h SetParamer.c SetParamer.h Turn_Decision.c Turn_Decision.h
    Make_Desicion/Speed_Control/: Speed_Control.c Speed_control.h
  group Math
    ./: math_car.c math_car.h
  group Peripheral/ITG-3200_Operation
    Peripheral_Oparation/: ITG3200.c ITG3200.h
  group Peripheral/MMA8451Q_Operation
    Peripheral_Oparation/: MMA8451Q.c MMA8451Q.h
  group Peripheral/OLED
    OLED/: OLED.c OLED.h
  group Peripheral/Peripheral_Oparation
    Peripheral_Oparation/: Peripheral_Oparation.c Peripheral_Oparation.h
  group Peripheral/SD_System
    SD_System/: fat32txt.c SD_driver.c SD_driver.h SD_System.h
  group Peripheral/ZLG7290
    ZLG7290/: key_7290.c key_7290.h
  group Simple_AD
    Simple_AD/: Simple_AD.c Simple_AD.h
  group Source
    Source/: AllHeaders.h Common_Define.h main.c
  group System_Init
    System_Init/: System_Init.c System_Init.h
